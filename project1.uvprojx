# Keil uVision project project1.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.7.0
  cpu: IRAM(0x1FFFF000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: project1
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .;.\RTE\_Target_1;.\RTE\Device\MKL25Z128xxx4
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Group 1
    ./: main.c pid.c motor.c angle_sensor.c control.c encoder.c
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.0
